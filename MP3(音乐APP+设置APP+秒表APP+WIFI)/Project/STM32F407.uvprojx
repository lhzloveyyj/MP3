# Keil uVision project STM32F407.uvprojx, settings and files
target STM32F4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\Libraries\CMSIS\Include;..\Libraries\inc;..\User\Hardware;..\User\Software;..\Libraries\STM32F4x7_ETH_Driver\inc;..\User\FATFS\exfuns;..\User\FATFS\src;..\User\HELIX\pub;..\User\HELIX\real;..\Freertos\portable\RVDS\ARM_CM4F;..\Freertos\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER_SOFTWARE
    ../User/Software/: main.c mp3Player.c
  group USER_HARDWARE
    ../User/Hardware/: delay.c led.c usart.c stm32f4xx_it.c dac.c sdio_sdcard.c malloc.c ADC.c key.c music.c mpu6050.c myiic.c esp8266.c usart3.c time7.c weather.c lcd.c lcd_init.c SPI.c pwm.c
  group LIBRARY
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_dac.c stm32f4xx_sdio.c stm32f4xx_adc.c stm32f4xx_spi.c
  group CMSIS
    ../Libraries/CMSIS/Source/: system_stm32f4xx.c
  group STARTUP
    ../Libraries/CMSIS/Source/: startup_stm32f40xx.s
  group FATFS
    ../User/FATFS/src/: diskio.c ff.c
    ../User/FATFS/exfuns/: exfuns.c fattester.c
    ../User/FATFS/src/option/: cc936.c
  group HELIX
    ../User/HELIX/: mp3dec.c mp3tabs.c
    ../User/HELIX/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../User/HELIX/real/arm/: asmmisc.s asmpoly_thumb2.s
  group FreeRTOS_CODE
    ../Freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../Freertos/portable/MemMang/: heap_4.c
    ../Freertos/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.5.0
